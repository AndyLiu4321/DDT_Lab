Commit message: update d1h_description

File: source/ddt_lab/data/robots/d1h/urdf/y1v0h_description.urdf (robot description, URDF)
Before this commit: robot wl2_description, 10 links, 9 joints
Links:
- link F_base_link: geometry collision box size=0.31 0.12 0.04; collision box size=0.375 0.15 0.19
